# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32A403ACGU7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\..\libraries\cmsis\cm4;..\..\libraries\cmsis\dsp\ComputeLibrary;..\..\libraries\cmsis\dsp\include;..\..\libraries\cmsis\dsp\PrivateInclude;..\..\libraries\cmsis\dsp\Source;..\..\libraries\cmsis\dsp;..\..\libraries\drivers\inc;..\..\libraries\drivers\src;..\..\libraries\drivers;..\bsp\inc;..\bsp\src;..\bsp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../bsp/src/: main.c at32f403a_407_int.c at32f403a_407_clock.c
  group bsp
    ../bsp/src/: IOstream.c Initial.c SerialPort.c InteriorAD.c Command.c SPIdrive.c Function.c Temperature.c chokeDelay.c W25q128.c tmc_2209.c CommandList.c Encoder.c tmc_2209_comm.c
  group library
    ../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
